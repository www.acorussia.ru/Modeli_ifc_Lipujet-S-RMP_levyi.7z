Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-23T15:56:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 15:56:27 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{C4F8130A-D4B8-46FF-BB4D-83ED712DEC44}\ifc * Database version: 5507 * Database creation date: Tue May 23 15:56:25 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 15:56:25 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 15:56:25 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowController: std, ZZZ_do not use_ME_ST_filling device for Lipurex_ACO:std:21528
In: Level 1
Type - Description: Filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: Filling device; LOD: LOD 400; Manufacturer: ACO; Model: ACO filling device for Lipurex; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO
Type - Plumbing - p_c01_flow: 0.105944 m3/s
Type - Structural - RSen_S_net_mass: 2.3
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Offset: 2385.8 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
General - RSen_C_intended_use: Entwässerungssysteme
Identity Data - Mark: 4; RSen_C_code_article: 7602.00.25; RSen_C_code_gtin: 04002626143303; RSen_C_description: ACO Fülleinheit für Lipurex-O,-OD,-R,-RD
Other - option: 0; Family: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Family and Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Type: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std; Type Id: ZZZ_do not use_ME_ST_filling device for Lipurex_ACO: std
Phasing - Phase Created: New Construction

# IfcFlowTerminal: NS20, ME_ST_lipurat rse extension stage 2_ACO:NS20:21516
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: Steel, Blue, Stainless Steel, Brushed, PVC, White
Type - Electrical - Loads - RSen_E_c01_load_classification: Power; RSen_E_powerfactor: 1
Type - Electrical Engineering - RSen_E_c01_3_phase: yes; RSen_E_c01_current: 16 A; RSen_E_c01_number_of_poles: 3; RSen_E_c01_subclass_motor: yes; RSen_E_c01_voltage: 400 V
Type - General - installation_manual: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0lNMDAwOTczNl9fMjA1ODg0LnBkZg==/IM0009736__205884.pdf; instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9GQV9GcmVpYXVmc3RlbGx1bmdfcnVuZF91bmRfb3ZhbF9fNDUwMDUucGRm/EBA_FA_Freiaufstellung_rund_und_oval__45005.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Runde-Bauform-Edelstahl-1.4571/Lipurat-RSE-Ausbaustufe-2; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 20; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS20
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; extension_stage_lookup_table_name: lipurex_rse_extension_stage_2; Family Name: ME_ST_lipurat rse extension stage 2_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS20
Constraints - clearance_zone: no; DN_sanitary: yes; filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; OD_sanitary: no; Offset: 0 mm; right: yes; sight_glass: yes
Dimensions - Area: 31.1098 m2; D: 210 mm; D1: 1750 mm; DN: 200 mm; H: 2270.8 mm; H1: 1935 mm; H2: 1885 mm; H3: 2320 mm; H4: 2640 mm; L1: 2050 mm; L2: 120 mm; L3: 150 mm; vent_DN: 100 mm; Volume: 0.0494751 m3
Electrical - Loads - RSen_E_c01_apparent_power_phase_1: 2300 W; RSen_E_c01_apparent_power_phase_2: 2300 W; RSen_E_c01_apparent_power_phase_3: 2300 W
Electrical Engineering - RSen_E_c01_apparent_power: 6900 W; RSen_E_connected_fase: 1
General - RSen_P_c01_diameter: 200 mm; RSen_P_c02_diameter: 200 mm; RSen_P_c03_diameter: 100 mm; RSen_P_c04_diameter: 20 mm; RSen_P_c05_diameter: 65 mm
Identity Data - Mark: 1; RSen_C_code_article: 7520.73.61; RSen_C_code_gtin: 04002626142337; RSen_C_description: ACO Fettabscheid. Lipurat RSE NS20 Dirabsg.+HD-Rg.rd.rechts
Mechanical - RSen_P_c04_flow: 0 m3/s; System Classification: Sanitary,Vent,Domestic Cold Water,Other,Controls,Power
Model Properties - cleaninghead_X: 500 mm; clearance_back: 1075 mm; clearance_entry: 2025 mm; clearance_exit: 1525 mm; clearance_front: 1625 mm; clearance_top: 3240 mm; D_drain: 76 mm; DN_drain: 65 mm; drain_X: 215 mm; drain_Y: 280 mm; drain_Z: 2327 mm; motor_position: 232 deg; motor_Y: 886.7 mm; motor_Z: 943 mm; switchbox_position: 135 deg; switchbox_Y: 975 mm; switchbox_Z: 2047.8 mm
Other - cold_water_connector: cw in; connector_escape_message: Nicht verwenden; Family: ME_ST_lipurat rse extension stage 2_ACO: NS20; Family and Type: ME_ST_lipurat rse extension stage 2_ACO: NS20; help_connected_phase: 3; L2_half: 60 mm; lookup_table_name: lipurex_r_basic; no_option: 0; option: 1; options_lookup_table_name: lipurex_r_options; R: 105 mm; R1: 875 mm; Type: ME_ST_lipurat rse extension stage 2_ACO: NS20; Type Id: ME_ST_lipurat rse extension stage 2_ACO: NS20
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 0.8 m3; overall_capacity: 3.82 m3; sludge_trap_capacity: 2.11 m3
Structural - RSen_S_gross_mass: 4396; RSen_S_net_mass: 576

# IfcFlowTerminal: std, ZZZ_do not use_ME_ST_lipurex_r_options_ACO:std:21517
In: Level 1
Type - PredefinedType: GREASEINTERCEPTOR; Material: Plastic, White, HDPE, Red, Stainless Steel, Brushed
Type - Identity Data - Manufacturer: Aco; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_lipurex_r_options_ACO
Pset_ManufacturerTypeInformation - Manufacturer: Aco
Pset_DistributionFlowElementCommon - Reference: std
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; inlet_angle: 0 deg; left: no; logo: yes; Offset: 0 mm; right: yes; sight_glass: yes; Moves With Nearby Elements: no
Dimensions - acces_exit_X_pos: 575 mm; access_entry_diameter: 504 mm; access_entry_X_position: 400 mm; Area: 18.7825 m2; bottom_diam: 1750 mm; bottom_length: 395 mm; bottom_offset: 0 mm; cover_Z_position: 2308.8 mm; D: 210 mm; D1: 1750 mm; disposalpump_angle: 29 deg; disposalpump_flange_OD: 220 mm; disposalpump_flange length: 23.5 mm; disposalpump_OD: 114.3 mm; disposalpump_X: 1075 mm; disposalpump_Z: 135.5 mm; DN: 200 mm; footing_radius: 805 mm; glass_Z_position: 1817.8 mm; glasstube_diam: 336 mm; glasstube_length: 1793 mm; H: 2270.8 mm; H1: 1935 mm; H2: 1885 mm; H3: 2320 mm; H4: 2640 mm; inlet_length: 1025 mm; L1: 2050 mm; L2: 120 mm; L3: 150 mm; leg_offset: 90 deg; legnumber: 0; logo_Z: 1318 mm; outlet_length: 1045 mm; rib_diameter: 1794 mm; rib_number: 2; rib_thickness: 35 mm; rib1_Z: 782 mm; rib2_Z: 1542 mm; vent_DN: 100 mm; vent_OD: 110 mm; vent_X: 180 mm; vent_Y: 1000 mm; Volume: 5.70014 m3; waterinlet_angle: -20 deg; waterinlet_OD: 76.1 mm; waterinlet_X: 989 mm; waterinlet_Z: 2110.8 mm
General - RSen_P_c01_diameter: 200 mm; RSen_P_c02_diameter: 200 mm
Identity Data - Mark: 2
Model Properties - glass_position: 90 deg; glass_X_position: 896.5 mm; grease_measure_end_angle: 265 deg; grease_measure_start_angle: 270 deg; grease_measure_X: 0.1 mm; grease_measure_Y: 1200 mm; grease_measure_Z: 2270.8 mm; heatrod_position: 90 deg; heatrod_Z_position: 1473 mm
Other - blend_position: 395 mm; bottom_plate: yes; Family: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; Family and Type: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; filling_device_option: 0; grease_measure_option: 1; heatrod_option: 1; L2_half: 60 mm; logo_position: 90 deg; lookup_table_name: lipurex_r_basic; options_lookup_table_name: lipurex_r_options; R: 105 mm; R1: 875 mm; sight_glass_option: 0; Type: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; type_index: 20; Type Id: ZZZ_do not use_ME_ST_lipurex_r_options_ACO: std; vent_length: 50 mm; waterinlet_end_angle: 25 deg; waterinlet_height: 275 mm; waterinlet_start_angle: 20 deg
Phasing - Phase Created: New Construction

# IfcWindow: std, ZZZ_do not use_ME_PE_viewing window Lipurex_ACO:std:21527
In: Level 1
Type - Description: Viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Viewing window; LOD: LOD 400; Manufacturer: ACO; Model: ACO viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO
Type - Structural - RSen_S_net_mass: 2.3
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
BaseQuantities - Area: 0.0878948 m2
Constraints - Moves With Nearby Elements: no; Offset: 1817.8 mm
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - Mark: 3; RSen_C_code_article: 7602.00.26; RSen_C_code_gtin: 04002626143310; RSen_C_description: ACO Schauglas LW 200 f. Lipurex-O,-OD,-R,-RD
Other - Family: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std; Family and Type: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std; Type Id: ZZZ_do not use_ME_PE_viewing window Lipurex_ACO: std
Phasing - Phase Created: New Construction
